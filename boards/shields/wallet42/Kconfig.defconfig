## boards/shields/wallet42/Kconfig.defconfig
```kconfig
if SHIELD_WALLET42

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "wallet42"

endif
```
